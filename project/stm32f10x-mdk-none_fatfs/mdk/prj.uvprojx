# Keil uVision project prj.uvprojx, settings and files
target prj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\..\bsp\CMSIS\CM3\CoreSupport;..\..\..\bsp\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\bsp\STM32F10x_StdPeriph_Driver\inc;..\..\..\hal\include;..\..\..\hal\device\stm32f10x;..\..\..\hal\device\stm32f10x\dts-hal\gpio;..\..\..\hal\device\stm32f10x\dts-hal\interrupt;..\..\..\hal\device\stm32f10x\dts-hal\uart;..\..\..\hal\device\swsim;..\..\..\hal\device\object\spi;..\..\..\hal\driver;..\..\..\lib\include;..\..\..\fs\fatfs\source;..\bsp;..\hal;..\lib;..\fs
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ../../../bsp/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../../bsp/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c
  group hal
    ../../../hal/driver/: w25qxx.c
    ../../../hal/device/stm32f10x/: stm32f10x_hal_spi.c
    ../../../hal/device/swsim/: swsim_hal_spi.c
    ../../../hal/device/stm32f10x/dts-hal/gpio/: dts_hal_gpio.c
    ../../../hal/device/stm32f10x/dts-hal/uart/: dts_hal_uart.c
    ../../../hal/lib/: uhal_com.c blist.c dts_hal_uart_printf.c
    ../../../hal/device/stm32f10x/dts-hal/interrupt/: dts_hal_intterupt.c
  group app
    ../app/: main.c
    ../../app/: fs_test.c
  group lib
    ../../../lib/delay/: delay_ms_stm32f10x.c delay_us_stm32f10x.c delay.c
  group hw
    ../../hw/: board_led.c board_w25q128.c stm32f10x_spi_obj.c stm32f10x_uart.c
  group fs
    ../../../fs/fatfs/source/: ff.c ffsystem.c
    ../fs/: diskio.c
