# Keil uVision project p.uvprojx, settings and files
target p (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: p
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..\..\bsp\CMSIS\CM3\CoreSupport;..\..\..\bsp\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\bsp\STM32F10x_StdPeriph_Driver\inc;..\bsp;..\dts.usb\include;..\..\..\bsp\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ../dts.usb/app/: stm32f10x_usb_uart.c main.c
  group bsp
    ../../../bsp/STM32_USB-FS-Device_Driver/src/: usb_regs.c usb_mem.c
    ../../../bsp/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_gpio.c stm32f10x_exti.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../../bsp/CMSIS/CM3/CoreSupport/: core_cm3.c
  group dts.usb
    ../dts.usb/: dts_usb_com_dev.c dts_usb_dev.c dts_usb_control_transfer.c dts_usb_std_dev_req.c dts_usb_bulk_transfer.c dts_usb_com_dev_line_coding.c
    ../dts.usb/driver/: stm32f10x_usb_driver.c
    ../dts.usb/app/: usb_desc.c
