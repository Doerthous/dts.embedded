# Keil uVision project prj.uvprojx, settings and files
target prj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\..\bsp\CMSIS\CM3\CoreSupport;..\..\..\bsp\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\bsp\STM32F10x_StdPeriph_Driver\inc;..\..\..\hal\include;..\..\..\hal\device\stm32f10x;..\..\..\hal\device\stm32f10x\dts-hal\gpio;..\..\..\hal\device\stm32f10x\dts-hal\interrupt;..\..\..\hal\device\stm32f10x\dts-hal\uart;..\..\..\lib\include;..\bsp;..\hal;..\lib;..\..\hw;..\..\..\hal\driver;..\..\..\hal\device\stm32f10x\dts-hal\timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ../../../bsp/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../../bsp/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_fsmc.c
  group hal
    ../../../hal/driver/: ili9xxx.c
    ../../../hal/device/stm32f10x/dts-hal/gpio/: dts_hal_gpio.c
    ../../../hal/device/stm32f10x/dts-hal/interrupt/: dts_hal_intterupt.c
    ../../../hal/lib/: uhal_com.c blist.c dts_hal_uart_printf.c
    ../../../hal/device/stm32f10x/dts-hal/uart/: dts_hal_uart.c
    ../../../hal/device/stm32f10x/dts-hal/timer/: dts_hal_timer.c
    ../../../hal/driver/ili9xxx/: ili9xxx_stm32f10x_fsmc.c ili9xxx_stm32f10x_io.c
  group app
    ../../../hal/driver/: ili9xxx_test.c
    ../app/: startup.c
  group lib
    ../../../lib/delay/: delay_ms_stm32f10x.c delay_us_stm32f10x.c delay.c
    ../../../lib/: dts_elib_tick_dts-hal.c
  group hw
    ../../hw/: board_led.c stm32f10x_uart.c stm32f10x_tim.c
