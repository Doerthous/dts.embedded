# Keil uVision project prj.uvprojx, settings and files
target prj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\..\bsp\CMSIS\CM3\CoreSupport;..\..\..\bsp\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\bsp\STM32F10x_StdPeriph_Driver\inc;..\..\..\os\FreeRTOS\FreeRTOS\Source\include;..\..\..\os\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\net\dts.net\include;..\..\..\lib\include;..\..\..\net\dts.net\dts.datastruct\include;..\..\..\hal\include;..\..\..\hal\device\stm32f10x\dts-hal\gpio;..\..\..\hal\device\stm32f10x\dts-hal\interrupt;..\..\..\hal\device\stm32f10x\dts-hal\timer;..\..\..\hal\device\stm32f10x\dts-hal\spi;..\..\..\hal\device\stm32f10x\dts-hal\uart;..\..\..\hal\device\stm32f10x\;..\..\..\hal\driver;..\bsp;..\os;..\net;..\lib;..\hal;..\..\..\os\dts.eos\include;..\..\..\os\dts.eos\rtos\freertos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ../../../bsp/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../bsp/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_usart.c
    ../bsp/: startup_stm32f10x_hd.s
  group app
    ../../app/: isr_thrd.c
    ../../sys/: freertos_startup_1.c
    ../app/: init_thrd.c
  group hw
    ../../hw/: board_enc28j60.c board_led.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_uart.c
  group hal
    ../../../hal/device/stm32f10x/dts-hal/uart/: dts_hal_uart.c
    ../../../hal/device/stm32f10x/dts-hal/timer/: dts_hal_timer.c
    ../../../hal/device/stm32f10x/dts-hal/gpio/: dts_hal_gpio.c
    ../../../hal/device/stm32f10x/dts-hal/interrupt/: dts_hal_intterupt.c
    ../../../hal/device/stm32f10x/dts-hal/spi/: dts_hal_spi.c
    ../../../hal/driver/: enc28j60.c
    ../../../hal/lib/: dts_hal_uart_printf.c blist.c uhal_com.c
  group net
    ../../../net/dts.net/: dts_net_arp.c dts_net_dblk.c dts_net_dhcp.c dts_net_ether.c dts_net_ether_arp.c dts_net_icmp.c dts_net_ip.c dts_net_sys.c dts_net_tcp.c dts_net_udp.c
    ../../../net/dts.net/dts.net.mem.impl/: dts_net_mem_list.c
    ../../../net/dts.net/dts.datastruct/: dts_datastruct_list.c
    ../../../net/dts.net/socket/: socket.c
  group lib
    ../../../lib/: dts_elib_timer.c
    ../../../lib/delay/: delay.c delay_ms_dts.cos.c delay_us_stm32f10x.c
  group os
    ../../../os/FreeRTOS/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../os/FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../os/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
