# Keil uVision project p.uvprojx, settings and files
target p (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: p
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\..\..\bsp\CMSIS\CM3\CoreSupport;..\..\..\bsp\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\bsp\STM32F10x_StdPeriph_Driver\inc;..\..\..\os\FreeRTOS\FreeRTOS\Source\include;..\..\..\os\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\bsp;..\os
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../: main.c
  group bsp
    ../../../bsp/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../bsp/: startup_stm32f10x_hd.s
  group os
    ../../../os/FreeRTOS/FreeRTOS/Source/: timers.c list.c queue.c tasks.c
    ../../../os/FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../os/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
