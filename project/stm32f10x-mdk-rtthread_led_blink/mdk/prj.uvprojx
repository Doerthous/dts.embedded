# Keil uVision project prj.uvprojx, settings and files
target prj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\stm32f10x-mdk-rtthread_led_blink\bsp;..\..\stm32f10x-mdk-rtthread_led_blink\os;..\..\..\bsp\CMSIS\CM3\CoreSupport;..\..\..\bsp\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\os\rt-thread\include;..\..\..\bsp\STM32F10x_StdPeriph_Driver\inc;..\..\..\hal\include;..\..\..\hal\device\stm32f10x;..\..\..\hal\device\stm32f10x\dts-hal\gpio;..\..\..\lib\include;..\hal;..\lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ../../../bsp/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../bsp/: board.c
    ../../../bsp/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c
  group os
    ../../../os/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../os/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group app
    ../app/: startup.c
    ../../app/: led_blink.c
  group hal
    ../../../hal/device/stm32f10x/dts-hal/gpio/: dts_hal_gpio.c
  group lib
    ../../../lib/delay/: delay_ms_rtt.c delay.c delay_us_stm32f10x.c
  group hw
    ../../hw/: board_led.c
